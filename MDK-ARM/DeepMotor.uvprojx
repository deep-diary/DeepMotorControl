# Keil uVision project DeepMotor.uvprojx, settings and files
target DeepMotor (6190000::V6.19::ARMCLANG)
  device: STM32G431VBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: DeepMotor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32G431xx,USE_HAL_DRIVER,__TARGET_FPU_VFP,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Matlab;../EEPROM_Emul;../EEPROM_Emul/Core;../EEPROM_Emul/Porting;../Middlewares/ST/ARM/DSP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1f000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Matlab
    ../Matlab/: FOC.c FOC_data.c
  group Application/User/Core
    ../Core/Src/: scara.c can_uart_exchange.c timer_tasks.c camera_platform.c main.c gpio.c adc.c comp.c dac.c dma.c fdcan.c i2c.c usart.c opamp.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_ll_rcc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
  group Middlewares/Library/DSP Library/DSP Library
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Middlewares/ST/ARM/DSP/Lib/: arm_cortexM4l_math.lib
  group EEPROM
    ../EEPROM_Emul/: NVMemory.c stm32g4xx_ll_rcc.h
    ../EEPROM_Emul/Porting/STM32G4/: flash_interface.c
    ../EEPROM_Emul/Core/: eeprom_emul.c CRC16.c
software components: CMSIS:CORE 4.3.0
